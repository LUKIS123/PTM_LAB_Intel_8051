# Keil uVision project lab4.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: lab4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab4.asm
